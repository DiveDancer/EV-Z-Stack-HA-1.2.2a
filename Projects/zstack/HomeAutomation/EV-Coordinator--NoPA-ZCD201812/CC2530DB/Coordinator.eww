<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Coordinator.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>Coordinator</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>Coordinator</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>Coordinator</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>Coordinator</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


